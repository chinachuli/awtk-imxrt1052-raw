# IAR project awtk_gui_demo.ewp, settings and files
configuration awtk_gui_demo (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMXRT1052DVL6B; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; SKIP_SYSCLK_INIT; HAS_AWTK_CONFIG
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../..; ../../CMSIS/Include; ../../devices; ../../devices/MIMXRT1052/drivers; ../../components/ft5406_rt; ../../devices/MIMXRT1052/drivers; ../../devices/MIMXRT1052; ../../devices/MIMXRT1052/utilities/str; ../../devices/MIMXRT1052/utilities/debug_console; ../../components/uart; ../../components/serial_manager; ../../components/lists; ../../middleware/zlg_awtk/awtk/src/ext_widgets; ../../middleware/zlg_awtk/awtk; ../../middleware/zlg_awtk/awtk/src; ../../middleware/zlg_awtk/awtk/3rd; ../../middleware/zlg_awtk/awtk/3rd/SDL/include; ../../middleware/zlg_awtk/awtk/3rd/nanovg/base; ../../middleware/zlg_awtk/awtk/3rd/nanovg; ../../middleware/zlg_awtk/awtk/3rd/agge; ../../middleware/zlg_awtk/awtk/3rd/cairo; ../../middleware/zlg_awtk/awtk/3rd/nanovg; ../../middleware/zlg_awtk/awtk/3rd/libunibreak; ../../middleware/zlg_awtk/awtk/3rd/gpinyin/include; ../../middleware/zlg_awtk/awtk-port
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkOutputFile: awtk_gui_demo.out
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor_sdram_cl.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group awtk/awtk/3rd\agge\agge
    ../../middleware/zlg_awtk/awtk/3rd/agge/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
  group awtk/awtk/3rd\gpinyin\src
    ../../middleware/zlg_awtk/awtk/3rd/gpinyin/src/: dictlist.cpp dicttrie.cpp lpicache.cpp matrixsearch.cpp mystdlib.cpp ngram.cpp pinyinime.cpp searchutility.cpp spellingtrie.cpp splparser.cpp utf16char.cpp
  group awtk/awtk/3rd\libunibreak
    ../../middleware/zlg_awtk/awtk/3rd/libunibreak/: emojidef.c graphemebreak.c linebreak.c linebreakdata.c linebreakdef.c unibreakbase.c unibreakdef.c wordbreak.c
  group awtk/awtk/3rd\nanovg\agge
    ../../middleware/zlg_awtk/awtk/3rd/nanovg/agge/: nanovg_agge.cpp nanovg_vertex.cpp
  group awtk/awtk/3rd\nanovg\base
    ../../middleware/zlg_awtk/awtk/3rd/nanovg/base/: nanovg.c
  group awtk/awtk/src
    ../../middleware/zlg_awtk/awtk/src/: awtk_global.c
  group awtk/awtk/src/base
    ../../middleware/zlg_awtk/awtk/src/base/: assets_manager.c bitmap.c canvas.c children_layouter.c children_layouter_factory.c clip_board.c dialog.c dialog_highlighter.c dialog_highlighter_factory.c enums.c event_queue.c events.c font.c font_loader.c font_manager.c glyph_cache.c hscrollable.c idle.c image_base.c image_loader.c image_manager.c input_device_status.c input_engine.c input_method.c layout.c lcd.c lcd_profile.c line_break.c locale_info.c main_loop.c native_window.c self_layouter.c self_layouter_factory.c shortcut.c style.c style_const.c style_factory.c style_mutable.c suggest_words.c system_info.c text_edit.c theme.c timer.c ui_builder.c ui_feedback.c ui_loader.c velocity.c vgcanvas.c widget.c widget_animator.c widget_animator_factory_null.c widget_animator_manager.c widget_factory.c widget_vtable.c window.c window_animator.c window_animator_factory.c window_base.c window_manager.c
  group awtk/awtk/src/blend
    ../../middleware/zlg_awtk/awtk/src/blend/: blend_image_bgr565_bgr565.c blend_image_bgr565_bgra8888.c blend_image_bgr565_rgba8888.c blend_image_bgr888_bgr565.c blend_image_bgr888_bgra8888.c blend_image_bgr888_rgba8888.c blend_image_bgra8888_bgr565.c blend_image_bgra8888_bgra8888.c blend_image_bgra8888_rgba8888.c blend_image_rgb565_bgr565.c blend_image_rgb565_bgra8888.c blend_image_rgb565_rgba8888.c blend_image_rgba8888_bgr565.c blend_image_rgba8888_bgra8888.c blend_image_rgba8888_rgba8888.c fill_image_abgr8888.c fill_image_argb8888.c fill_image_bgr565.c fill_image_bgr888.c fill_image_bgra8888.c fill_image_rgb565.c fill_image_rgba8888.c image_g2d.c rotate_image_bgr565.c rotate_image_bgr888.c rotate_image_bgra8888.c rotate_image_rgb565.c rotate_image_rgba8888.c soft_g2d.c stm32_g2d.c
  group awtk/awtk/src/clip_board
    ../../middleware/zlg_awtk/awtk/src/clip_board/: clip_board_default.c clip_board_sdl.c
  group awtk/awtk/src/dialog_highlighters
    ../../middleware/zlg_awtk/awtk/src/dialog_highlighters/: dialog_highlighter_builtins.c dialog_highlighter_default.c
  group awtk/awtk/src/ext_widgets
    ../../middleware/zlg_awtk/awtk/src/ext_widgets/: candidates.c canvas_widget.c children_layouter_list_view.c color_component.c color_picker.c combo_box_ex.c digit_clock.c draggable.c ext_widgets.c gif_image.c guage.c guage_pointer.c hscroll_label.c image_animation.c image_value.c keyboard.c line_number.c list_item.c list_view.c list_view_h.c mledit.c mutable_image.c progress_circle.c rgb_and_hsv.c rich_text.c rich_text_node.c rich_text_parser.c rich_text_render_node.c scroll_bar.c scroll_view.c slide_indicator.c slide_menu.c slide_view.c svg_image.c switch.c text_selector.c time_clock.c
  group awtk/awtk/src/font_loader
    ../../middleware/zlg_awtk/awtk/src/font_loader/: font_loader_bitmap.c font_loader_ft.c font_loader_stb.c
  group awtk/awtk/src/image_loader
    ../../middleware/zlg_awtk/awtk/src/image_loader/: image_loader_stb.c
  group awtk/awtk/src/input_engines
    ../../middleware/zlg_awtk/awtk/src/input_engines/: input_engine_pinyin.cpp
  group awtk/awtk/src/input_methods
    ../../middleware/zlg_awtk/awtk/src/input_methods/: input_method_creator.c
  group awtk/awtk/src/layouters
    ../../middleware/zlg_awtk/awtk/src/layouters/: children_layouter_builtins.c children_layouter_default.c children_layouter_parser.c self_layouter_builtins.c self_layouter_default.c self_layouter_menu.c self_layouter_parser.c
  group awtk/awtk/src/lcd
    ../../middleware/zlg_awtk/awtk/src/lcd/: lcd_mem_bgr565.c lcd_mem_bgra8888.c lcd_mem_rgba8888.c
  group awtk/awtk/src/main_loop
    ../../middleware/zlg_awtk/awtk/src/main_loop/: main_loop_simple.c
  group awtk/awtk/src/misc
    ../../middleware/zlg_awtk/awtk/src/misc/: new.cpp test_cpp.cpp
  group awtk/awtk/src/native_window
    ../../middleware/zlg_awtk/awtk/src/native_window/: native_window_raw.c
  group awtk/awtk/src/svg
    ../../middleware/zlg_awtk/awtk/src/svg/: bsvg.c bsvg_builder.c bsvg_draw.c bsvg_to_svg.c svg_path.c svg_path_parser.c svg_shape.c svg_to_bsvg.c
  group awtk/awtk/src/tkc
    ../../middleware/zlg_awtk/awtk/src/tkc/: buffer.c color.c color_parser.c compressor.c crc.c darray.c date_time.c easing.c emitter.c event.c event_source.c event_source_fd.c event_source_idle.c event_source_manager.c event_source_manager_default.c event_source_timer.c expr_eval.c fs.c func_call_parser.c idle_info.c idle_manager.c int_str.c iostream.c istream.c matrix.c mem.c named_value.c object.c object_array.c object_default.c ostream.c path.c rect.c ring_buffer.c rom_fs.c slist.c socket_pair.c str.c str_str.c time_now.c timer_info.c timer_manager.c tokenizer.c utf8.c utils.c value.c value_desc.c wstr.c
  group awtk/awtk/src/ui_loader
    ../../middleware/zlg_awtk/awtk/src/ui_loader/: ui_binary_writer.c ui_builder_default.c ui_loader_default.c ui_loader_xml.c ui_serializer.c ui_xml_writer.c window_open.c
  group awtk/awtk/src/vgcanvas
    ../../middleware/zlg_awtk/awtk/src/vgcanvas/: vgcanvas_nanovg_soft.c
  group awtk/awtk/src/widget_animators
    ../../middleware/zlg_awtk/awtk/src/widget_animators/: widget_animator_factory.c widget_animator_prop.c widget_animator_prop2.c widget_animator_scroll.c
  group awtk/awtk/src/widgets
    ../../middleware/zlg_awtk/awtk/src/widgets/: app_bar.c button.c button_group.c calibration_win.c check_button.c color_tile.c column.c combo_box.c combo_box_item.c dialog_client.c dialog_helper.c dialog_title.c dragger.c edit.c grid.c grid_item.c group_box.c image.c label.c overlay.c pages.c popup.c progress_bar.c row.c slider.c spin_box.c system_bar.c tab_button.c tab_button_group.c tab_control.c view.c widgets.c
  group awtk/awtk/src/window_animators
    ../../middleware/zlg_awtk/awtk/src/window_animators/: window_animator_builtins.c window_animator_center_scale.c window_animator_common.c window_animator_fade.c window_animator_htranslate.c window_animator_popdown.c window_animator_popup.c window_animator_slide.c window_animator_slide_down.c window_animator_slide_left.c window_animator_slide_right.c window_animator_slide_up.c window_animator_vtranslate.c
  group awtk/awtk/src/window_manager
    ../../middleware/zlg_awtk/awtk/src/window_manager/: window_manager_default.c
  group awtk/awtk/src/xml
    ../../middleware/zlg_awtk/awtk/src/xml/: xml_builder.c xml_parser.c
  group awtk/awtk-demos
    ../../middleware/zlg_awtk/awtk-demos/: assets.c demo_main.c demo_ui_app.c demo_vg_app.c
  group awtk/awtk-port
    ../../middleware/zlg_awtk/awtk-port/: main_loop_rt1052_raw.c mutex_null.c platform.c
  group board
    ../: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
  group component/lists
    ../../components/lists/: generic_list.c
  group component/serial_manager
    ../../components/serial_manager/: serial_manager.c serial_port_uart.c
  group component/uart
    ../../components/uart/: lpuart_adapter.c
  group device
    ../../devices/MIMXRT1052/: system_MIMXRT1052.c
  group doc
    ../: readme.txt
  group drivers
    ../../devices/MIMXRT1052/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexio.c fsl_flexio_camera.c fsl_flexio_camera_edma.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_mculcd.c fsl_flexio_mculcd_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_ocotp.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_tempmon.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
  group source
    ../: bsp_i2c_touch.c bsp_lcd.c bsp_systick.c core_delay.c gt9xx.c main.c
  group startup
    ../../devices/MIMXRT1052/iar/: startup_MIMXRT1052.s
  group utilities
    ../../devices/MIMXRT1052/utilities/: fsl_assert.c
    ../../devices/MIMXRT1052/utilities/debug_console/: fsl_debug_console.c
    ../../devices/MIMXRT1052/utilities/str/: fsl_str.c
  group xip
    ./: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
