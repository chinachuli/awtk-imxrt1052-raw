<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>awtk_gui_demo</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-STAT</name>
            <archiveVersion>261</archiveVersion>
            <data>
                <version>261</version>
                <cstatargs>
                    <useExtraArgs>0</useExtraArgs>
                    <extraArgs></extraArgs>
                    <analyzeTimeoutEnabled>1</analyzeTimeoutEnabled>
                    <analyzeTimeout>600</analyzeTimeout>
                    <enableParallel>1</enableParallel>
                    <parallelThreads>2</parallelThreads>
                    <enableFalsePositives>0</enableFalsePositives>
                    <messagesLimitEnabled>1</messagesLimitEnabled>
                    <messagesLimit>100</messagesLimit>
                </cstatargs>
                <cstat_settings>
                    <cstat_version>1.5.4</cstat_version>
                    <checks_tree>
                        <package name="STDCHECKS" enabled="true">
                            <group enabled="true" name="ARR">
                                <check name="ARR-inv-index-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr-pos" enabled="true" />
                                <check name="ARR-inv-index-ptr" enabled="true" />
                                <check name="ARR-inv-index" enabled="true" />
                                <check name="ARR-neg-index" enabled="true" />
                                <check name="ARR-uninit-index" enabled="true" />
                            </group>
                            <group enabled="true" name="ATH">
                                <check name="ATH-cmp-float" enabled="true" />
                                <check name="ATH-cmp-unsign-neg" enabled="true" />
                                <check name="ATH-cmp-unsign-pos" enabled="true" />
                                <check name="ATH-div-0-assign" enabled="true" />
                                <check name="ATH-div-0-cmp-aft" enabled="false" />
                                <check name="ATH-div-0-cmp-bef" enabled="true" />
                                <check name="ATH-div-0-interval" enabled="true" />
                                <check name="ATH-div-0-pos" enabled="true" />
                                <check name="ATH-div-0-unchk-global" enabled="true" />
                                <check name="ATH-div-0-unchk-local" enabled="true" />
                                <check name="ATH-div-0-unchk-param" enabled="true" />
                                <check name="ATH-div-0" enabled="true" />
                                <check name="ATH-inc-bool" enabled="true" />
                                <check name="ATH-malloc-overrun" enabled="true" />
                                <check name="ATH-neg-check-nonneg" enabled="true" />
                                <check name="ATH-neg-check-pos" enabled="true" />
                                <check name="ATH-new-overrun" enabled="true" />
                                <check name="ATH-overflow-cast" enabled="false" />
                                <check name="ATH-overflow" enabled="true" />
                                <check name="ATH-shift-bounds" enabled="true" />
                                <check name="ATH-shift-neg" enabled="true" />
                                <check name="ATH-sizeof-by-sizeof" enabled="true" />
                            </group>
                            <group enabled="true" name="CAST">
                                <check name="CAST-old-style" enabled="false" />
                            </group>
                            <group enabled="true" name="CATCH">
                                <check name="CATCH-object-slicing" enabled="true" />
                                <check name="CATCH-xtor-bad-member" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMA">
                                <check name="COMMA-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="COMMENT">
                                <check name="COMMENT-nested" enabled="true" />
                            </group>
                            <group enabled="true" name="CONST">
                                <check name="CONST-member-ret" enabled="true" />
                            </group>
                            <group enabled="true" name="COP">
                                <check name="COP-alloc-ctor" enabled="false" />
                                <check name="COP-assign-op-ret" enabled="true" />
                                <check name="COP-assign-op-self" enabled="true" />
                                <check name="COP-assign-op" enabled="true" />
                                <check name="COP-copy-ctor" enabled="true" />
                                <check name="COP-dealloc-dtor" enabled="false" />
                                <check name="COP-dtor-throw" enabled="true" />
                                <check name="COP-dtor" enabled="true" />
                                <check name="COP-init-order" enabled="true" />
                                <check name="COP-init-uninit" enabled="true" />
                                <check name="COP-member-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="CPU">
                                <check name="CPU-ctor-call-virt" enabled="true" />
                                <check name="CPU-ctor-implicit" enabled="false" />
                                <check name="CPU-delete-throw" enabled="true" />
                                <check name="CPU-delete-void" enabled="true" />
                                <check name="CPU-dtor-call-virt" enabled="true" />
                                <check name="CPU-malloc-class" enabled="true" />
                                <check name="CPU-nonvirt-dtor" enabled="true" />
                                <check name="CPU-return-ref-to-class-data" enabled="true" />
                            </group>
                            <group enabled="true" name="DECL">
                                <check name="DECL-implicit-int" enabled="false" />
                            </group>
                            <group enabled="true" name="DEFINE">
                                <check name="DEFINE-hash-multiple" enabled="true" />
                            </group>
                            <group enabled="true" name="ENUM">
                                <check name="ENUM-bounds" enabled="false" />
                            </group>
                            <group enabled="true" name="EXP">
                                <check name="EXP-cond-assign" enabled="true" />
                                <check name="EXP-dangling-else" enabled="true" />
                                <check name="EXP-loop-exit" enabled="true" />
                                <check name="EXP-main-ret-int" enabled="false" />
                                <check name="EXP-null-stmt" enabled="false" />
                                <check name="EXP-stray-semicolon" enabled="false" />
                            </group>
                            <group enabled="true" name="EXPR">
                                <check name="EXPR-const-overflow" enabled="true" />
                            </group>
                            <group enabled="true" name="FPT">
                                <check name="FPT-cmp-null" enabled="true" />
                                <check name="FPT-literal" enabled="false" />
                                <check name="FPT-misuse" enabled="true" />
                            </group>
                            <group enabled="true" name="FUNC">
                                <check name="FUNC-implicit-decl" enabled="false" />
                                <check name="FUNC-unprototyped-all" enabled="false" />
                                <check name="FUNC-unprototyped-used" enabled="true" />
                            </group>
                            <group enabled="true" name="INCLUDE">
                                <check name="INCLUDE-c-file" enabled="false" />
                            </group>
                            <group enabled="true" name="INT">
                                <check name="INT-use-signed-as-unsigned-pos" enabled="false" />
                                <check name="INT-use-signed-as-unsigned" enabled="true" />
                            </group>
                            <group enabled="true" name="ITR">
                                <check name="ITR-end-cmp-aft" enabled="true" />
                                <check name="ITR-end-cmp-bef" enabled="true" />
                                <check name="ITR-invalidated" enabled="true" />
                                <check name="ITR-mismatch-alg" enabled="false" />
                                <check name="ITR-store" enabled="false" />
                                <check name="ITR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="LIB">
                                <check name="LIB-bsearch-overrun-pos" enabled="false" />
                                <check name="LIB-bsearch-overrun" enabled="false" />
                                <check name="LIB-fn-unsafe" enabled="false" />
                                <check name="LIB-fread-overrun-pos" enabled="false" />
                                <check name="LIB-fread-overrun" enabled="true" />
                                <check name="LIB-memchr-overrun-pos" enabled="false" />
                                <check name="LIB-memchr-overrun" enabled="true" />
                                <check name="LIB-memcpy-overrun-pos" enabled="false" />
                                <check name="LIB-memcpy-overrun" enabled="true" />
                                <check name="LIB-memset-overrun-pos" enabled="false" />
                                <check name="LIB-memset-overrun" enabled="true" />
                                <check name="LIB-putenv" enabled="false" />
                                <check name="LIB-qsort-overrun-pos" enabled="false" />
                                <check name="LIB-qsort-overrun" enabled="false" />
                                <check name="LIB-return-const" enabled="true" />
                                <check name="LIB-return-error" enabled="true" />
                                <check name="LIB-return-leak" enabled="true" />
                                <check name="LIB-return-neg" enabled="true" />
                                <check name="LIB-return-null" enabled="true" />
                                <check name="LIB-sprintf-overrun" enabled="false" />
                                <check name="LIB-std-sort-overrun-pos" enabled="false" />
                                <check name="LIB-std-sort-overrun" enabled="true" />
                                <check name="LIB-strcat-overrun-pos" enabled="false" />
                                <check name="LIB-strcat-overrun" enabled="true" />
                                <check name="LIB-strcpy-overrun-pos" enabled="false" />
                                <check name="LIB-strcpy-overrun" enabled="true" />
                                <check name="LIB-strncat-overrun-pos" enabled="false" />
                                <check name="LIB-strncat-overrun" enabled="true" />
                                <check name="LIB-strncmp-overrun-pos" enabled="false" />
                                <check name="LIB-strncmp-overrun" enabled="true" />
                                <check name="LIB-strncpy-overrun-pos" enabled="false" />
                                <check name="LIB-strncpy-overrun" enabled="true" />
                            </group>
                            <group enabled="true" name="LOGIC">
                                <check name="LOGIC-overload" enabled="false" />
                            </group>
                            <group enabled="true" name="MEM">
                                <check name="MEM-delete-array-op" enabled="true" />
                                <check name="MEM-delete-op" enabled="true" />
                                <check name="MEM-double-free-alias" enabled="true" />
                                <check name="MEM-double-free-some" enabled="true" />
                                <check name="MEM-double-free" enabled="true" />
                                <check name="MEM-free-field" enabled="true" />
                                <check name="MEM-free-fptr" enabled="true" />
                                <check name="MEM-free-no-alloc-struct" enabled="false" />
                                <check name="MEM-free-no-alloc" enabled="false" />
                                <check name="MEM-free-no-use" enabled="true" />
                                <check name="MEM-free-op" enabled="true" />
                                <check name="MEM-free-struct-field" enabled="true" />
                                <check name="MEM-free-variable-alias" enabled="true" />
                                <check name="MEM-free-variable" enabled="true" />
                                <check name="MEM-leak-alias" enabled="true" />
                                <check name="MEM-leak" enabled="false" />
                                <check name="MEM-malloc-arith" enabled="false" />
                                <check name="MEM-malloc-diff-type" enabled="true" />
                                <check name="MEM-malloc-sizeof-ptr" enabled="true" />
                                <check name="MEM-malloc-sizeof" enabled="true" />
                                <check name="MEM-malloc-strlen" enabled="false" />
                                <check name="MEM-realloc-diff-type" enabled="true" />
                                <check name="MEM-return-free" enabled="true" />
                                <check name="MEM-return-no-assign" enabled="true" />
                                <check name="MEM-stack-global-field" enabled="true" />
                                <check name="MEM-stack-global" enabled="true" />
                                <check name="MEM-stack-param-ref" enabled="true" />
                                <check name="MEM-stack-param" enabled="true" />
                                <check name="MEM-stack-pos" enabled="true" />
                                <check name="MEM-stack-ref" enabled="true" />
                                <check name="MEM-stack" enabled="true" />
                                <check name="MEM-use-free-all" enabled="true" />
                                <check name="MEM-use-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="PTR">
                                <check name="PTR-arith-field" enabled="true" />
                                <check name="PTR-arith-stack" enabled="true" />
                                <check name="PTR-arith-var" enabled="true" />
                                <check name="PTR-cmp-str-lit" enabled="true" />
                                <check name="PTR-null-assign-fun-pos" enabled="false" />
                                <check name="PTR-null-assign-pos" enabled="false" />
                                <check name="PTR-null-assign" enabled="true" />
                                <check name="PTR-null-cmp-aft" enabled="true" />
                                <check name="PTR-null-cmp-bef-fun" enabled="true" />
                                <check name="PTR-null-cmp-bef" enabled="true" />
                                <check name="PTR-null-fun-pos" enabled="true" />
                                <check name="PTR-null-literal-pos" enabled="false" />
                                <check name="PTR-overload" enabled="false" />
                                <check name="PTR-singleton-arith-pos" enabled="false" />
                                <check name="PTR-singleton-arith" enabled="true" />
                                <check name="PTR-unchk-param-some" enabled="true" />
                                <check name="PTR-unchk-param" enabled="false" />
                                <check name="PTR-uninit-pos" enabled="false" />
                                <check name="PTR-uninit" enabled="true" />
                            </group>
                            <group enabled="true" name="RED">
                                <check name="RED-alloc-zero-bytes" enabled="false" />
                                <check name="RED-case-reach" enabled="false" />
                                <check name="RED-cmp-always" enabled="false" />
                                <check name="RED-cmp-never" enabled="false" />
                                <check name="RED-cond-always" enabled="false" />
                                <check name="RED-cond-const-assign" enabled="true" />
                                <check name="RED-cond-const-expr" enabled="false" />
                                <check name="RED-cond-const" enabled="false" />
                                <check name="RED-cond-never" enabled="false" />
                                <check name="RED-dead" enabled="true" />
                                <check name="RED-expr" enabled="false" />
                                <check name="RED-func-no-effect" enabled="false" />
                                <check name="RED-local-hides-global" enabled="true" />
                                <check name="RED-local-hides-local" enabled="false" />
                                <check name="RED-local-hides-member" enabled="false" />
                                <check name="RED-local-hides-param" enabled="true" />
                                <check name="RED-no-effect" enabled="false" />
                                <check name="RED-self-assign" enabled="true" />
                                <check name="RED-unused-assign" enabled="true" />
                                <check name="RED-unused-param" enabled="false" />
                                <check name="RED-unused-return-val" enabled="false" />
                                <check name="RED-unused-val" enabled="false" />
                                <check name="RED-unused-var-all" enabled="true" />
                            </group>
                            <group enabled="true" name="RESOURCE">
                                <check name="RESOURCE-deref-file" enabled="false" />
                                <check name="RESOURCE-double-close" enabled="true" />
                                <check name="RESOURCE-file-no-close-all" enabled="true" />
                                <check name="RESOURCE-file-pos-neg" enabled="false" />
                                <check name="RESOURCE-file-use-after-close" enabled="true" />
                                <check name="RESOURCE-implicit-deref-file" enabled="false" />
                                <check name="RESOURCE-write-ronly-file" enabled="true" />
                            </group>
                            <group enabled="true" name="SIZEOF">
                                <check name="SIZEOF-side-effect" enabled="true" />
                            </group>
                            <group enabled="true" name="SPC">
                                <check name="SPC-order" enabled="true" />
                                <check name="SPC-uninit-arr-all" enabled="false" />
                                <check name="SPC-uninit-struct-field-heap" enabled="true" />
                                <check name="SPC-uninit-struct-field" enabled="false" />
                                <check name="SPC-uninit-struct" enabled="true" />
                                <check name="SPC-uninit-var-all" enabled="true" />
                                <check name="SPC-uninit-var-some" enabled="true" />
                                <check name="SPC-volatile-reads" enabled="false" />
                                <check name="SPC-volatile-writes" enabled="false" />
                            </group>
                            <group enabled="true" name="STRUCT">
                                <check name="STRUCT-signed-bit" enabled="false" />
                            </group>
                            <group enabled="true" name="SWITCH">
                                <check name="SWITCH-fall-through" enabled="true" />
                            </group>
                            <group enabled="true" name="THROW">
                                <check name="THROW-empty" enabled="false" />
                                <check name="THROW-main" enabled="false" />
                                <check name="THROW-null" enabled="true" />
                                <check name="THROW-ptr" enabled="true" />
                                <check name="THROW-static" enabled="true" />
                                <check name="THROW-unhandled" enabled="true" />
                            </group>
                            <group enabled="true" name="UNION">
                                <check name="UNION-overlap-assign" enabled="true" />
                                <check name="UNION-type-punning" enabled="true" />
                            </group>
                        </package>
                        <package name="CERT" enabled="false">
                            <group enabled="true" name="CERT-EXP">
                                <check name="CERT-EXP19-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-FIO">
                                <check name="CERT-FIO37-C" enabled="true" />
                                <check name="CERT-FIO38-C" enabled="true" />
                            </group>
                            <group enabled="true" name="CERT-SIG">
                                <check name="CERT-SIG31-C" enabled="true" />
                            </group>
                        </package>
                        <package name="SECURITY" enabled="false">
                            <group enabled="true" name="SEC-BUFFER">
                                <check name="SEC-BUFFER-memory-leak-alias" enabled="true" />
                                <check name="SEC-BUFFER-memory-leak" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-memset-overrun" enabled="true" />
                                <check name="SEC-BUFFER-qsort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-qsort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-sprintf-overrun" enabled="true" />
                                <check name="SEC-BUFFER-std-sort-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-std-sort-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strcpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strcpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncat-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncat-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncmp-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncmp-overrun" enabled="true" />
                                <check name="SEC-BUFFER-strncpy-overrun-pos" enabled="false" />
                                <check name="SEC-BUFFER-strncpy-overrun" enabled="true" />
                                <check name="SEC-BUFFER-tainted-alloc-size" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy-length" enabled="true" />
                                <check name="SEC-BUFFER-tainted-copy" enabled="true" />
                                <check name="SEC-BUFFER-tainted-index" enabled="true" />
                                <check name="SEC-BUFFER-tainted-offset" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-all" enabled="true" />
                                <check name="SEC-BUFFER-use-after-free-some" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-DIV-0">
                                <check name="SEC-DIV-0-compare-after" enabled="true" />
                                <check name="SEC-DIV-0-compare-before" enabled="true" />
                                <check name="SEC-DIV-0-tainted" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-FILEOP">
                                <check name="SEC-FILEOP-open-no-close" enabled="true" />
                                <check name="SEC-FILEOP-path-traversal" enabled="false" />
                                <check name="SEC-FILEOP-use-after-close" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-INJECTION">
                                <check name="SEC-INJECTION-sql" enabled="false" />
                                <check name="SEC-INJECTION-xpath" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-LOOP">
                                <check name="SEC-LOOP-tainted-bound" enabled="true" />
                            </group>
                            <group enabled="true" name="SEC-NULL">
                                <check name="SEC-NULL-assignment-fun-pos" enabled="false" />
                                <check name="SEC-NULL-assignment" enabled="true" />
                                <check name="SEC-NULL-cmp-aft" enabled="true" />
                                <check name="SEC-NULL-cmp-bef-fun" enabled="true" />
                                <check name="SEC-NULL-cmp-bef" enabled="true" />
                                <check name="SEC-NULL-literal-pos" enabled="false" />
                            </group>
                            <group enabled="true" name="SEC-STRING">
                                <check name="SEC-STRING-format-string" enabled="true" />
                                <check name="SEC-STRING-hard-coded-credentials" enabled="false" />
                            </group>
                        </package>
                        <package name="MISRAC2004" enabled="false">
                            <group enabled="true" name="MISRAC2004-1">
                                <check name="MISRAC2004-1.1" enabled="true" />
                                <check name="MISRAC2004-1.2_a" enabled="true" />
                                <check name="MISRAC2004-1.2_b" enabled="true" />
                                <check name="MISRAC2004-1.2_c" enabled="true" />
                                <check name="MISRAC2004-1.2_d" enabled="true" />
                                <check name="MISRAC2004-1.2_e" enabled="true" />
                                <check name="MISRAC2004-1.2_f" enabled="true" />
                                <check name="MISRAC2004-1.2_g" enabled="true" />
                                <check name="MISRAC2004-1.2_h" enabled="true" />
                                <check name="MISRAC2004-1.2_i" enabled="true" />
                                <check name="MISRAC2004-1.2_j" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-2">
                                <check name="MISRAC2004-2.1" enabled="true" />
                                <check name="MISRAC2004-2.2" enabled="true" />
                                <check name="MISRAC2004-2.3" enabled="true" />
                                <check name="MISRAC2004-2.4" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-5">
                                <check name="MISRAC2004-5.2" enabled="true" />
                                <check name="MISRAC2004-5.3" enabled="true" />
                                <check name="MISRAC2004-5.4" enabled="true" />
                                <check name="MISRAC2004-5.5" enabled="false" />
                                <check name="MISRAC2004-5.6" enabled="false" />
                                <check name="MISRAC2004-5.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-6">
                                <check name="MISRAC2004-6.1" enabled="true" />
                                <check name="MISRAC2004-6.2" enabled="true" />
                                <check name="MISRAC2004-6.3" enabled="false" />
                                <check name="MISRAC2004-6.4" enabled="true" />
                                <check name="MISRAC2004-6.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-7">
                                <check name="MISRAC2004-7.1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8">
                                <check name="MISRAC2004-8.1" enabled="true" />
                                <check name="MISRAC2004-8.2" enabled="true" />
                                <check name="MISRAC2004-8.3" enabled="true" />
                                <check name="MISRAC2004-8.5_a" enabled="true" />
                                <check name="MISRAC2004-8.5_b" enabled="true" />
                                <check name="MISRAC2004-8.6" enabled="true" />
                                <check name="MISRAC2004-8.7" enabled="true" />
                                <check name="MISRAC2004-8.8_a" enabled="true" />
                                <check name="MISRAC2004-8.8_b" enabled="true" />
                                <check name="MISRAC2004-8.12" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-8 10">
                                <check name="MISRAC2004-8.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-9">
                                <check name="MISRAC2004-9.1_a" enabled="true" />
                                <check name="MISRAC2004-9.1_b" enabled="true" />
                                <check name="MISRAC2004-9.1_c" enabled="true" />
                                <check name="MISRAC2004-9.2" enabled="true" />
                                <check name="MISRAC2004-9.3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-10">
                                <check name="MISRAC2004-10.1_a" enabled="true" />
                                <check name="MISRAC2004-10.1_b" enabled="true" />
                                <check name="MISRAC2004-10.1_c" enabled="true" />
                                <check name="MISRAC2004-10.1_d" enabled="true" />
                                <check name="MISRAC2004-10.2_a" enabled="true" />
                                <check name="MISRAC2004-10.2_b" enabled="true" />
                                <check name="MISRAC2004-10.2_c" enabled="true" />
                                <check name="MISRAC2004-10.2_d" enabled="true" />
                                <check name="MISRAC2004-10.3" enabled="true" />
                                <check name="MISRAC2004-10.4" enabled="true" />
                                <check name="MISRAC2004-10.5" enabled="true" />
                                <check name="MISRAC2004-10.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-11">
                                <check name="MISRAC2004-11.1" enabled="true" />
                                <check name="MISRAC2004-11.3" enabled="false" />
                                <check name="MISRAC2004-11.4" enabled="false" />
                                <check name="MISRAC2004-11.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-12">
                                <check name="MISRAC2004-12.1" enabled="false" />
                                <check name="MISRAC2004-12.2_a" enabled="true" />
                                <check name="MISRAC2004-12.2_b" enabled="true" />
                                <check name="MISRAC2004-12.2_c" enabled="true" />
                                <check name="MISRAC2004-12.3" enabled="true" />
                                <check name="MISRAC2004-12.4" enabled="true" />
                                <check name="MISRAC2004-12.5" enabled="true" />
                                <check name="MISRAC2004-12.6_a" enabled="false" />
                                <check name="MISRAC2004-12.6_b" enabled="false" />
                                <check name="MISRAC2004-12.7" enabled="true" />
                                <check name="MISRAC2004-12.8" enabled="true" />
                                <check name="MISRAC2004-12.9" enabled="true" />
                                <check name="MISRAC2004-12.10" enabled="true" />
                                <check name="MISRAC2004-12.11" enabled="false" />
                                <check name="MISRAC2004-12.12_a" enabled="true" />
                                <check name="MISRAC2004-12.12_b" enabled="true" />
                                <check name="MISRAC2004-12.13" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2004-13">
                                <check name="MISRAC2004-13.1" enabled="true" />
                                <check name="MISRAC2004-13.2_a" enabled="false" />
                                <check name="MISRAC2004-13.2_b" enabled="false" />
                                <check name="MISRAC2004-13.2_c" enabled="false" />
                                <check name="MISRAC2004-13.2_d" enabled="false" />
                                <check name="MISRAC2004-13.2_e" enabled="false" />
                                <check name="MISRAC2004-13.3" enabled="true" />
                                <check name="MISRAC2004-13.4" enabled="true" />
                                <check name="MISRAC2004-13.5" enabled="true" />
                                <check name="MISRAC2004-13.6" enabled="true" />
                                <check name="MISRAC2004-13.7_a" enabled="true" />
                                <check name="MISRAC2004-13.7_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-14">
                                <check name="MISRAC2004-14.1" enabled="true" />
                                <check name="MISRAC2004-14.2" enabled="true" />
                                <check name="MISRAC2004-14.3" enabled="true" />
                                <check name="MISRAC2004-14.4" enabled="true" />
                                <check name="MISRAC2004-14.5" enabled="true" />
                                <check name="MISRAC2004-14.6" enabled="true" />
                                <check name="MISRAC2004-14.7" enabled="true" />
                                <check name="MISRAC2004-14.8_a" enabled="true" />
                                <check name="MISRAC2004-14.8_b" enabled="true" />
                                <check name="MISRAC2004-14.8_c" enabled="true" />
                                <check name="MISRAC2004-14.8_d" enabled="true" />
                                <check name="MISRAC2004-14.9" enabled="true" />
                                <check name="MISRAC2004-14.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-15">
                                <check name="MISRAC2004-15.0" enabled="true" />
                                <check name="MISRAC2004-15.1" enabled="true" />
                                <check name="MISRAC2004-15.2" enabled="true" />
                                <check name="MISRAC2004-15.3" enabled="true" />
                                <check name="MISRAC2004-15.4" enabled="true" />
                                <check name="MISRAC2004-15.5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-16">
                                <check name="MISRAC2004-16.1" enabled="true" />
                                <check name="MISRAC2004-16.2_a" enabled="true" />
                                <check name="MISRAC2004-16.2_b" enabled="true" />
                                <check name="MISRAC2004-16.3" enabled="true" />
                                <check name="MISRAC2004-16.4" enabled="true" />
                                <check name="MISRAC2004-16.5" enabled="true" />
                                <check name="MISRAC2004-16.7" enabled="true" />
                                <check name="MISRAC2004-16.8" enabled="true" />
                                <check name="MISRAC2004-16.9" enabled="true" />
                                <check name="MISRAC2004-16.10" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-17">
                                <check name="MISRAC2004-17.1_a" enabled="true" />
                                <check name="MISRAC2004-17.1_b" enabled="true" />
                                <check name="MISRAC2004-17.1_c" enabled="true" />
                                <check name="MISRAC2004-17.2" enabled="true" />
                                <check name="MISRAC2004-17.3" enabled="true" />
                                <check name="MISRAC2004-17.4_a" enabled="true" />
                                <check name="MISRAC2004-17.4_b" enabled="true" />
                                <check name="MISRAC2004-17.5" enabled="true" />
                                <check name="MISRAC2004-17.6_a" enabled="true" />
                                <check name="MISRAC2004-17.6_b" enabled="true" />
                                <check name="MISRAC2004-17.6_c" enabled="true" />
                                <check name="MISRAC2004-17.6_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-18">
                                <check name="MISRAC2004-18.1" enabled="true" />
                                <check name="MISRAC2004-18.2" enabled="true" />
                                <check name="MISRAC2004-18.4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-19">
                                <check name="MISRAC2004-19.1" enabled="false" />
                                <check name="MISRAC2004-19.2" enabled="false" />
                                <check name="MISRAC2004-19.4" enabled="true" />
                                <check name="MISRAC2004-19.5" enabled="true" />
                                <check name="MISRAC2004-19.6" enabled="true" />
                                <check name="MISRAC2004-19.7" enabled="false" />
                                <check name="MISRAC2004-19.10" enabled="true" />
                                <check name="MISRAC2004-19.12" enabled="true" />
                                <check name="MISRAC2004-19.13" enabled="false" />
                                <check name="MISRAC2004-19.15" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2004-20">
                                <check name="MISRAC2004-20.1" enabled="true" />
                                <check name="MISRAC2004-20.2" enabled="true" />
                                <check name="MISRAC2004-20.3_a" enabled="true" />
                                <check name="MISRAC2004-20.3_b" enabled="true" />
                                <check name="MISRAC2004-20.3_c" enabled="true" />
                                <check name="MISRAC2004-20.3_d" enabled="true" />
                                <check name="MISRAC2004-20.3_e" enabled="true" />
                                <check name="MISRAC2004-20.3_f" enabled="true" />
                                <check name="MISRAC2004-20.3_g" enabled="true" />
                                <check name="MISRAC2004-20.3_h" enabled="true" />
                                <check name="MISRAC2004-20.3_i" enabled="true" />
                                <check name="MISRAC2004-20.4" enabled="true" />
                                <check name="MISRAC2004-20.5" enabled="true" />
                                <check name="MISRAC2004-20.6" enabled="true" />
                                <check name="MISRAC2004-20.7" enabled="true" />
                                <check name="MISRAC2004-20.8" enabled="true" />
                                <check name="MISRAC2004-20.9" enabled="true" />
                                <check name="MISRAC2004-20.10" enabled="true" />
                                <check name="MISRAC2004-20.11" enabled="true" />
                                <check name="MISRAC2004-20.12" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC2012" enabled="false">
                            <group enabled="true" name="MISRAC2012-Dir-4">
                                <check name="MISRAC2012-Dir-4.3" enabled="true" />
                                <check name="MISRAC2012-Dir-4.4" enabled="false" />
                                <check name="MISRAC2012-Dir-4.5" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.6_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.7_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.8" enabled="false" />
                                <check name="MISRAC2012-Dir-4.9" enabled="false" />
                                <check name="MISRAC2012-Dir-4.10" enabled="true" />
                                <check name="MISRAC2012-Dir-4.11_a" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_b" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_c" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_d" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_e" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_f" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_g" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_h" enabled="false" />
                                <check name="MISRAC2012-Dir-4.11_i" enabled="false" />
                                <check name="MISRAC2012-Dir-4.12" enabled="false" />
                                <check name="MISRAC2012-Dir-4.13_b" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_c" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_d" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_e" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_f" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_g" enabled="true" />
                                <check name="MISRAC2012-Dir-4.13_h" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-1">
                                <check name="MISRAC2012-Rule-1.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_c" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_d" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_e" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_f" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_g" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_h" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_i" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_j" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_k" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_m" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_n" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_o" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_p" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_q" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_r" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_s" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_t" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_u" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_v" enabled="true" />
                                <check name="MISRAC2012-Rule-1.3_w" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-2">
                                <check name="MISRAC2012-Rule-2.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-2.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-2.3" enabled="false" />
                                <check name="MISRAC2012-Rule-2.4" enabled="false" />
                                <check name="MISRAC2012-Rule-2.5" enabled="false" />
                                <check name="MISRAC2012-Rule-2.6" enabled="false" />
                                <check name="MISRAC2012-Rule-2.7" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-3">
                                <check name="MISRAC2012-Rule-3.1" enabled="true" />
                                <check name="MISRAC2012-Rule-3.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-5">
                                <check name="MISRAC2012-Rule-5.1" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.2_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.3_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-5.5_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-5.6" enabled="true" />
                                <check name="MISRAC2012-Rule-5.7" enabled="true" />
                                <check name="MISRAC2012-Rule-5.8" enabled="true" />
                                <check name="MISRAC2012-Rule-5.9" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-6">
                                <check name="MISRAC2012-Rule-6.1" enabled="true" />
                                <check name="MISRAC2012-Rule-6.2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-7">
                                <check name="MISRAC2012-Rule-7.1" enabled="true" />
                                <check name="MISRAC2012-Rule-7.2" enabled="true" />
                                <check name="MISRAC2012-Rule-7.3" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-7.4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-8">
                                <check name="MISRAC2012-Rule-8.1" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.4" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-8.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-8.7" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_a" enabled="false" />
                                <check name="MISRAC2012-Rule-8.9_b" enabled="false" />
                                <check name="MISRAC2012-Rule-8.10" enabled="true" />
                                <check name="MISRAC2012-Rule-8.11" enabled="false" />
                                <check name="MISRAC2012-Rule-8.12" enabled="true" />
                                <check name="MISRAC2012-Rule-8.13" enabled="false" />
                                <check name="MISRAC2012-Rule-8.14" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-9">
                                <check name="MISRAC2012-Rule-9.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_e" enabled="true" />
                                <check name="MISRAC2012-Rule-9.1_f" enabled="true" />
                                <check name="MISRAC2012-Rule-9.2" enabled="true" />
                                <check name="MISRAC2012-Rule-9.3" enabled="true" />
                                <check name="MISRAC2012-Rule-9.4" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-9.5_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-10">
                                <check name="MISRAC2012-Rule-10.1_R2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R4" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R5" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.1_R8" enabled="true" />
                                <check name="MISRAC2012-Rule-10.2" enabled="true" />
                                <check name="MISRAC2012-Rule-10.3" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-10.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-10.5" enabled="false" />
                                <check name="MISRAC2012-Rule-10.6" enabled="true" />
                                <check name="MISRAC2012-Rule-10.7" enabled="true" />
                                <check name="MISRAC2012-Rule-10.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-11">
                                <check name="MISRAC2012-Rule-11.1" enabled="true" />
                                <check name="MISRAC2012-Rule-11.2" enabled="true" />
                                <check name="MISRAC2012-Rule-11.3" enabled="true" />
                                <check name="MISRAC2012-Rule-11.4" enabled="false" />
                                <check name="MISRAC2012-Rule-11.5" enabled="false" />
                                <check name="MISRAC2012-Rule-11.6" enabled="true" />
                                <check name="MISRAC2012-Rule-11.7" enabled="true" />
                                <check name="MISRAC2012-Rule-11.8" enabled="true" />
                                <check name="MISRAC2012-Rule-11.9" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-12">
                                <check name="MISRAC2012-Rule-12.1" enabled="false" />
                                <check name="MISRAC2012-Rule-12.2" enabled="true" />
                                <check name="MISRAC2012-Rule-12.3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-13">
                                <check name="MISRAC2012-Rule-13.1" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-13.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-13.3" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_a" enabled="false" />
                                <check name="MISRAC2012-Rule-13.4_b" enabled="false" />
                                <check name="MISRAC2012-Rule-13.5" enabled="true" />
                                <check name="MISRAC2012-Rule-13.6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-14">
                                <check name="MISRAC2012-Rule-14.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.2" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.3_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_a" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_b" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_c" enabled="true" />
                                <check name="MISRAC2012-Rule-14.4_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-15">
                                <check name="MISRAC2012-Rule-15.1" enabled="false" />
                                <check name="MISRAC2012-Rule-15.2" enabled="true" />
                                <check name="MISRAC2012-Rule-15.3" enabled="true" />
                                <check name="MISRAC2012-Rule-15.4" enabled="false" />
                                <check name="MISRAC2012-Rule-15.5" enabled="false" />
                                <check name="MISRAC2012-Rule-15.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-15.6_e" enabled="true" />
                                <check name="MISRAC2012-Rule-15.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-16">
                                <check name="MISRAC2012-Rule-16.1" enabled="true" />
                                <check name="MISRAC2012-Rule-16.2" enabled="true" />
                                <check name="MISRAC2012-Rule-16.3" enabled="true" />
                                <check name="MISRAC2012-Rule-16.4" enabled="true" />
                                <check name="MISRAC2012-Rule-16.5" enabled="true" />
                                <check name="MISRAC2012-Rule-16.6" enabled="true" />
                                <check name="MISRAC2012-Rule-16.7" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-17">
                                <check name="MISRAC2012-Rule-17.1" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-17.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-17.3" enabled="true" />
                                <check name="MISRAC2012-Rule-17.4" enabled="true" />
                                <check name="MISRAC2012-Rule-17.5" enabled="false" />
                                <check name="MISRAC2012-Rule-17.6" enabled="true" />
                                <check name="MISRAC2012-Rule-17.7" enabled="true" />
                                <check name="MISRAC2012-Rule-17.8" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-18">
                                <check name="MISRAC2012-Rule-18.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.1_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.2" enabled="true" />
                                <check name="MISRAC2012-Rule-18.3" enabled="true" />
                                <check name="MISRAC2012-Rule-18.4" enabled="true" />
                                <check name="MISRAC2012-Rule-18.5" enabled="false" />
                                <check name="MISRAC2012-Rule-18.6_a" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_b" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_c" enabled="true" />
                                <check name="MISRAC2012-Rule-18.6_d" enabled="true" />
                                <check name="MISRAC2012-Rule-18.7" enabled="true" />
                                <check name="MISRAC2012-Rule-18.8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-19">
                                <check name="MISRAC2012-Rule-19.1" enabled="true" />
                                <check name="MISRAC2012-Rule-19.2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-20">
                                <check name="MISRAC2012-Rule-20.1" enabled="false" />
                                <check name="MISRAC2012-Rule-20.2" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c89" enabled="true" />
                                <check name="MISRAC2012-Rule-20.4_c99" enabled="true" />
                                <check name="MISRAC2012-Rule-20.5" enabled="false" />
                                <check name="MISRAC2012-Rule-20.7" enabled="true" />
                                <check name="MISRAC2012-Rule-20.10" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-21">
                                <check name="MISRAC2012-Rule-21.1" enabled="true" />
                                <check name="MISRAC2012-Rule-21.2" enabled="true" />
                                <check name="MISRAC2012-Rule-21.3" enabled="true" />
                                <check name="MISRAC2012-Rule-21.4" enabled="true" />
                                <check name="MISRAC2012-Rule-21.5" enabled="true" />
                                <check name="MISRAC2012-Rule-21.6" enabled="true" />
                                <check name="MISRAC2012-Rule-21.7" enabled="true" />
                                <check name="MISRAC2012-Rule-21.8" enabled="true" />
                                <check name="MISRAC2012-Rule-21.9" enabled="true" />
                                <check name="MISRAC2012-Rule-21.10" enabled="true" />
                                <check name="MISRAC2012-Rule-21.11" enabled="true" />
                                <check name="MISRAC2012-Rule-21.12_a" enabled="false" />
                                <check name="MISRAC2012-Rule-21.12_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC2012-Rule-22">
                                <check name="MISRAC2012-Rule-22.1_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.1_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.2_c" enabled="true" />
                                <check name="MISRAC2012-Rule-22.3" enabled="true" />
                                <check name="MISRAC2012-Rule-22.4" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_a" enabled="true" />
                                <check name="MISRAC2012-Rule-22.5_b" enabled="true" />
                                <check name="MISRAC2012-Rule-22.6" enabled="true" />
                            </group>
                        </package>
                        <package name="MISRAC++2008" enabled="false">
                            <group enabled="true" name="MISRAC++2008-0-1">
                                <check name="MISRAC++2008-0-1-1" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-2_c" enabled="true" />
                                <check name="MISRAC++2008-0-1-3" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_a" enabled="true" />
                                <check name="MISRAC++2008-0-1-4_b" enabled="true" />
                                <check name="MISRAC++2008-0-1-6" enabled="true" />
                                <check name="MISRAC++2008-0-1-7" enabled="true" />
                                <check name="MISRAC++2008-0-1-8" enabled="false" />
                                <check name="MISRAC++2008-0-1-9" enabled="true" />
                                <check name="MISRAC++2008-0-1-11" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-2">
                                <check name="MISRAC++2008-0-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-0-3">
                                <check name="MISRAC++2008-0-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-7">
                                <check name="MISRAC++2008-2-7-1" enabled="true" />
                                <check name="MISRAC++2008-2-7-2" enabled="true" />
                                <check name="MISRAC++2008-2-7-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-10">
                                <check name="MISRAC++2008-2-10-1" enabled="true" />
                                <check name="MISRAC++2008-2-10-2" enabled="true" />
                                <check name="MISRAC++2008-2-10-3" enabled="true" />
                                <check name="MISRAC++2008-2-10-4" enabled="true" />
                                <check name="MISRAC++2008-2-10-5" enabled="false" />
                                <check name="MISRAC++2008-2-10-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-2-13">
                                <check name="MISRAC++2008-2-13-2" enabled="true" />
                                <check name="MISRAC++2008-2-13-3" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_a" enabled="true" />
                                <check name="MISRAC++2008-2-13-4_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-1">
                                <check name="MISRAC++2008-3-1-1" enabled="true" />
                                <check name="MISRAC++2008-3-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-3-9">
                                <check name="MISRAC++2008-3-9-2" enabled="false" />
                                <check name="MISRAC++2008-3-9-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-4-5">
                                <check name="MISRAC++2008-4-5-1" enabled="true" />
                                <check name="MISRAC++2008-4-5-2" enabled="true" />
                                <check name="MISRAC++2008-4-5-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-0">
                                <check name="MISRAC++2008-5-0-1_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-1_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-2" enabled="false" />
                                <check name="MISRAC++2008-5-0-3" enabled="true" />
                                <check name="MISRAC++2008-5-0-4" enabled="true" />
                                <check name="MISRAC++2008-5-0-5" enabled="true" />
                                <check name="MISRAC++2008-5-0-6" enabled="true" />
                                <check name="MISRAC++2008-5-0-7" enabled="true" />
                                <check name="MISRAC++2008-5-0-8" enabled="true" />
                                <check name="MISRAC++2008-5-0-9" enabled="true" />
                                <check name="MISRAC++2008-5-0-10" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-13_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-14" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-15_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_a" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_b" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_c" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_d" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_e" enabled="true" />
                                <check name="MISRAC++2008-5-0-16_f" enabled="true" />
                                <check name="MISRAC++2008-5-0-19" enabled="true" />
                                <check name="MISRAC++2008-5-0-21" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-2">
                                <check name="MISRAC++2008-5-2-4" enabled="true" />
                                <check name="MISRAC++2008-5-2-5" enabled="true" />
                                <check name="MISRAC++2008-5-2-6" enabled="true" />
                                <check name="MISRAC++2008-5-2-7" enabled="true" />
                                <check name="MISRAC++2008-5-2-9" enabled="false" />
                                <check name="MISRAC++2008-5-2-10" enabled="false" />
                                <check name="MISRAC++2008-5-2-11_a" enabled="true" />
                                <check name="MISRAC++2008-5-2-11_b" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-3">
                                <check name="MISRAC++2008-5-3-1" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_a" enabled="true" />
                                <check name="MISRAC++2008-5-3-2_b" enabled="true" />
                                <check name="MISRAC++2008-5-3-3" enabled="true" />
                                <check name="MISRAC++2008-5-3-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-8">
                                <check name="MISRAC++2008-5-8-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-14">
                                <check name="MISRAC++2008-5-14-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-18">
                                <check name="MISRAC++2008-5-18-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-5-19">
                                <check name="MISRAC++2008-5-19-1" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-2">
                                <check name="MISRAC++2008-6-2-1" enabled="true" />
                                <check name="MISRAC++2008-6-2-2" enabled="true" />
                                <check name="MISRAC++2008-6-2-3" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-3">
                                <check name="MISRAC++2008-6-3-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_b" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_c" enabled="true" />
                                <check name="MISRAC++2008-6-3-1_d" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-4">
                                <check name="MISRAC++2008-6-4-1" enabled="true" />
                                <check name="MISRAC++2008-6-4-2" enabled="true" />
                                <check name="MISRAC++2008-6-4-3" enabled="true" />
                                <check name="MISRAC++2008-6-4-4" enabled="true" />
                                <check name="MISRAC++2008-6-4-5" enabled="true" />
                                <check name="MISRAC++2008-6-4-6" enabled="true" />
                                <check name="MISRAC++2008-6-4-7" enabled="true" />
                                <check name="MISRAC++2008-6-4-8" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-5">
                                <check name="MISRAC++2008-6-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-6-5-2" enabled="true" />
                                <check name="MISRAC++2008-6-5-3" enabled="true" />
                                <check name="MISRAC++2008-6-5-4" enabled="true" />
                                <check name="MISRAC++2008-6-5-6" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-6-6">
                                <check name="MISRAC++2008-6-6-1" enabled="true" />
                                <check name="MISRAC++2008-6-6-2" enabled="true" />
                                <check name="MISRAC++2008-6-6-4" enabled="true" />
                                <check name="MISRAC++2008-6-6-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-1">
                                <check name="MISRAC++2008-7-1-1" enabled="true" />
                                <check name="MISRAC++2008-7-1-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-2">
                                <check name="MISRAC++2008-7-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-4">
                                <check name="MISRAC++2008-7-4-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-7-5">
                                <check name="MISRAC++2008-7-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_a" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_b" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_c" enabled="true" />
                                <check name="MISRAC++2008-7-5-2_d" enabled="true" />
                                <check name="MISRAC++2008-7-5-4_a" enabled="false" />
                                <check name="MISRAC++2008-7-5-4_b" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-0">
                                <check name="MISRAC++2008-8-0-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-4">
                                <check name="MISRAC++2008-8-4-1" enabled="true" />
                                <check name="MISRAC++2008-8-4-3" enabled="true" />
                                <check name="MISRAC++2008-8-4-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-8-5">
                                <check name="MISRAC++2008-8-5-1_a" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_b" enabled="true" />
                                <check name="MISRAC++2008-8-5-1_c" enabled="true" />
                                <check name="MISRAC++2008-8-5-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-3">
                                <check name="MISRAC++2008-9-3-1" enabled="true" />
                                <check name="MISRAC++2008-9-3-2" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-5">
                                <check name="MISRAC++2008-9-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-9-6">
                                <check name="MISRAC++2008-9-6-2" enabled="true" />
                                <check name="MISRAC++2008-9-6-3" enabled="true" />
                                <check name="MISRAC++2008-9-6-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-12-1">
                                <check name="MISRAC++2008-12-1-1_a" enabled="true" />
                                <check name="MISRAC++2008-12-1-1_b" enabled="true" />
                                <check name="MISRAC++2008-12-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-0">
                                <check name="MISRAC++2008-15-0-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-1">
                                <check name="MISRAC++2008-15-1-2" enabled="true" />
                                <check name="MISRAC++2008-15-1-3" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-3">
                                <check name="MISRAC++2008-15-3-1" enabled="true" />
                                <check name="MISRAC++2008-15-3-2" enabled="false" />
                                <check name="MISRAC++2008-15-3-3" enabled="true" />
                                <check name="MISRAC++2008-15-3-4" enabled="true" />
                                <check name="MISRAC++2008-15-3-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-15-5">
                                <check name="MISRAC++2008-15-5-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-0">
                                <check name="MISRAC++2008-16-0-3" enabled="true" />
                                <check name="MISRAC++2008-16-0-4" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-2">
                                <check name="MISRAC++2008-16-2-2" enabled="true" />
                                <check name="MISRAC++2008-16-2-3" enabled="true" />
                                <check name="MISRAC++2008-16-2-4" enabled="true" />
                                <check name="MISRAC++2008-16-2-5" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-16-3">
                                <check name="MISRAC++2008-16-3-1" enabled="true" />
                                <check name="MISRAC++2008-16-3-2" enabled="false" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-17-0">
                                <check name="MISRAC++2008-17-0-1" enabled="true" />
                                <check name="MISRAC++2008-17-0-3" enabled="true" />
                                <check name="MISRAC++2008-17-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-0">
                                <check name="MISRAC++2008-18-0-1" enabled="true" />
                                <check name="MISRAC++2008-18-0-2" enabled="true" />
                                <check name="MISRAC++2008-18-0-3" enabled="true" />
                                <check name="MISRAC++2008-18-0-4" enabled="true" />
                                <check name="MISRAC++2008-18-0-5" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-2">
                                <check name="MISRAC++2008-18-2-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-4">
                                <check name="MISRAC++2008-18-4-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-18-7">
                                <check name="MISRAC++2008-18-7-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-19-3">
                                <check name="MISRAC++2008-19-3-1" enabled="true" />
                            </group>
                            <group enabled="true" name="MISRAC++2008-27-0">
                                <check name="MISRAC++2008-27-0-1" enabled="true" />
                            </group>
                        </package>
                    </checks_tree>
                </cstat_settings>
            </data>
        </settings>
        <settings>
            <name>RuntimeChecking</name>
            <archiveVersion>0</archiveVersion>
            <data>
                <version>2</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>GenRtcDebugHeap</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnableBoundsChecking</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrMem</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcTrackPointerBounds</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcCheckAccesses</name>
                    <state>1</state>
                </option>
                <option>
                    <name>GenRtcGenerateEntries</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcNrTrackedPointers</name>
                    <state>1000</state>
                </option>
                <option>
                    <name>GenRtcIntOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIncUnsigned</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntConversion</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclExplicit</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcIntShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcInclUnsignedShiftOverflow</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcUnhandledCase</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcDivByZero</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcEnable</name>
                    <state>0</state>
                </option>
                <option>
                    <name>GenRtcCheckPtrsNonInstrFunc</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
    </configuration>
    <group>
        <name>awtk</name>
        <group>
            <name>awtk</name>
            <group>
                <name>3rd\agge\agge</name>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\agge\agge\math.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\agge\agge\stroke.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\agge\agge\stroke_features.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\agge\agge\vector_rasterizer.cpp</name>
                </file>
            </group>
            <group>
                <name>3rd\gpinyin\src</name>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\dictlist.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\dicttrie.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\lpicache.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\matrixsearch.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\mystdlib.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\ngram.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\pinyinime.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\searchutility.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\spellingtrie.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\splparser.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\gpinyin\src\utf16char.cpp</name>
                </file>
            </group>
            <group>
                <name>3rd\libunibreak</name>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\libunibreak\emojidef.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\libunibreak\graphemebreak.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\libunibreak\linebreak.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\libunibreak\linebreakdata.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\libunibreak\linebreakdef.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\libunibreak\unibreakbase.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\libunibreak\unibreakdef.c</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\libunibreak\wordbreak.c</name>
                </file>
            </group>
            <group>
                <name>3rd\nanovg\agge</name>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\nanovg\agge\nanovg_agge.cpp</name>
                </file>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\nanovg\agge\nanovg_vertex.cpp</name>
                </file>
            </group>
            <group>
                <name>3rd\nanovg\base</name>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\3rd\nanovg\base\nanovg.c</name>
                </file>
            </group>
            <group>
                <name>src</name>
                <group>
                    <name>base</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\assets_manager.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\bitmap.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\canvas.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\children_layouter.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\children_layouter_factory.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\clip_board.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\dialog.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\dialog_highlighter.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\dialog_highlighter_factory.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\enums.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\event_queue.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\events.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\font.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\font_loader.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\font_manager.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\glyph_cache.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\hscrollable.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\idle.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\image_base.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\image_loader.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\image_manager.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\input_device_status.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\input_engine.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\input_method.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\layout.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\lcd.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\lcd_profile.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\line_break.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\locale_info.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\main_loop.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\native_window.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\self_layouter.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\self_layouter_factory.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\shortcut.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\style.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\style_const.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\style_factory.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\style_mutable.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\suggest_words.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\system_info.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\text_edit.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\theme.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\timer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\ui_builder.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\ui_feedback.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\ui_loader.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\velocity.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\vgcanvas.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\widget.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\widget_animator.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\widget_animator_factory_null.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\widget_animator_manager.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\widget_factory.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\widget_vtable.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\window.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\window_animator.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\window_animator_factory.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\window_base.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\base\window_manager.c</name>
                    </file>
                </group>
                <group>
                    <name>blend</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgr565_bgr565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgr565_bgra8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgr565_rgba8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgr888_bgr565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgr888_bgra8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgr888_rgba8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgra8888_bgr565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgra8888_bgra8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_bgra8888_rgba8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_rgb565_bgr565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_rgb565_bgra8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_rgb565_rgba8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_rgba8888_bgr565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_rgba8888_bgra8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\blend_image_rgba8888_rgba8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\fill_image_abgr8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\fill_image_argb8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\fill_image_bgr565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\fill_image_bgr888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\fill_image_bgra8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\fill_image_rgb565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\fill_image_rgba8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\image_g2d.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\rotate_image_bgr565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\rotate_image_bgr888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\rotate_image_bgra8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\rotate_image_rgb565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\rotate_image_rgba8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\soft_g2d.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\blend\stm32_g2d.c</name>
                    </file>
                </group>
                <group>
                    <name>clip_board</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\clip_board\clip_board_default.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\clip_board\clip_board_sdl.c</name>
                    </file>
                </group>
                <group>
                    <name>dialog_highlighters</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\dialog_highlighters\dialog_highlighter_builtins.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\dialog_highlighters\dialog_highlighter_default.c</name>
                    </file>
                </group>
                <group>
                    <name>ext_widgets</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\candidates.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\canvas_widget.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\children_layouter_list_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\color_component.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\color_picker.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\combo_box_ex.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\digit_clock.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\draggable.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\ext_widgets.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\gif_image.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\guage.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\guage_pointer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\hscroll_label.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\image_animation.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\image_value.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\keyboard.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\line_number.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\list_item.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\list_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\list_view_h.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\mledit.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\mutable_image.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\progress_circle.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\rgb_and_hsv.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\rich_text.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\rich_text_node.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\rich_text_parser.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\rich_text_render_node.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\scroll_bar.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\scroll_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\slide_indicator.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\slide_menu.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\slide_view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\svg_image.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\switch.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\text_selector.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ext_widgets\time_clock.c</name>
                    </file>
                </group>
                <group>
                    <name>font_loader</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\font_loader\font_loader_bitmap.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\font_loader\font_loader_ft.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\font_loader\font_loader_stb.c</name>
                    </file>
                </group>
                <group>
                    <name>image_loader</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\image_loader\image_loader_stb.c</name>
                    </file>
                </group>
                <group>
                    <name>input_engines</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\input_engines\input_engine_pinyin.cpp</name>
                    </file>
                </group>
                <group>
                    <name>input_methods</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\input_methods\input_method_creator.c</name>
                    </file>
                </group>
                <group>
                    <name>layouters</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\layouters\children_layouter_builtins.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\layouters\children_layouter_default.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\layouters\children_layouter_parser.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\layouters\self_layouter_builtins.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\layouters\self_layouter_default.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\layouters\self_layouter_menu.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\layouters\self_layouter_parser.c</name>
                    </file>
                </group>
                <group>
                    <name>lcd</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\lcd\lcd_mem_bgr565.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\lcd\lcd_mem_bgra8888.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\lcd\lcd_mem_rgba8888.c</name>
                    </file>
                </group>
                <group>
                    <name>main_loop</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\main_loop\main_loop_simple.c</name>
                    </file>
                </group>
                <group>
                    <name>misc</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\misc\new.cpp</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\misc\test_cpp.cpp</name>
                    </file>
                </group>
                <group>
                    <name>native_window</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\native_window\native_window_raw.c</name>
                    </file>
                </group>
                <group>
                    <name>svg</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\svg\bsvg.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\svg\bsvg_builder.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\svg\bsvg_draw.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\svg\bsvg_to_svg.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\svg\svg_path.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\svg\svg_path_parser.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\svg\svg_shape.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\svg\svg_to_bsvg.c</name>
                    </file>
                </group>
                <group>
                    <name>tkc</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\buffer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\color.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\color_parser.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\compressor.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\crc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\darray.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\date_time.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\easing.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\emitter.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\event.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\event_source.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\event_source_fd.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\event_source_idle.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\event_source_manager.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\event_source_manager_default.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\event_source_timer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\expr_eval.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\fs.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\func_call_parser.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\idle_info.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\idle_manager.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\int_str.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\iostream.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\istream.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\matrix.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\mem.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\named_value.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\object.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\object_array.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\object_default.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\ostream.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\path.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\rect.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\ring_buffer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\rom_fs.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\slist.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\socket_pair.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\str.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\str_str.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\time_now.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\timer_info.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\timer_manager.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\tokenizer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\utf8.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\utils.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\value.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\value_desc.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\tkc\wstr.c</name>
                    </file>
                </group>
                <group>
                    <name>ui_loader</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ui_loader\ui_binary_writer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ui_loader\ui_builder_default.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ui_loader\ui_loader_default.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ui_loader\ui_loader_xml.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ui_loader\ui_serializer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ui_loader\ui_xml_writer.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\ui_loader\window_open.c</name>
                    </file>
                </group>
                <group>
                    <name>vgcanvas</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\vgcanvas\vgcanvas_nanovg_soft.c</name>
                    </file>
                </group>
                <group>
                    <name>widget_animators</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widget_animators\widget_animator_factory.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widget_animators\widget_animator_prop.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widget_animators\widget_animator_prop2.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widget_animators\widget_animator_scroll.c</name>
                    </file>
                </group>
                <group>
                    <name>widgets</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\app_bar.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\button.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\button_group.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\calibration_win.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\check_button.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\color_tile.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\column.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\combo_box.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\combo_box_item.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\dialog_client.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\dialog_helper.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\dialog_title.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\dragger.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\edit.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\grid.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\grid_item.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\group_box.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\image.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\label.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\overlay.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\pages.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\popup.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\progress_bar.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\row.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\slider.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\spin_box.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\system_bar.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\tab_button.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\tab_button_group.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\tab_control.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\view.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\widgets\widgets.c</name>
                    </file>
                </group>
                <group>
                    <name>window_animators</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_builtins.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_center_scale.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_common.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_fade.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_htranslate.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_popdown.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_popup.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_slide.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_slide_down.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_slide_left.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_slide_right.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_slide_up.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_animators\window_animator_vtranslate.c</name>
                    </file>
                </group>
                <group>
                    <name>window_manager</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\window_manager\window_manager_default.c</name>
                    </file>
                </group>
                <group>
                    <name>xml</name>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\xml\xml_builder.c</name>
                    </file>
                    <file>
                        <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\xml\xml_parser.c</name>
                    </file>
                </group>
                <file>
                    <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk\src\awtk_global.c</name>
                </file>
            </group>
        </group>
        <group>
            <name>awtk-demos</name>
            <file>
                <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk-demos\assets.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk-demos\demo_main.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk-demos\demo_ui_app.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk-demos\demo_vg_app.c</name>
            </file>
        </group>
        <group>
            <name>awtk-port</name>
            <file>
                <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk-port\main_loop_rt1052_raw.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk-port\mutex_null.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\middleware\zlg_awtk\awtk-port\platform.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>board</name>
        <file>
            <name>$PROJ_DIR$\..\board.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\board.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\clock_config.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\clock_config.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\pin_mux.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\pin_mux.h</name>
        </file>
    </group>
    <group>
        <name>CMSIS</name>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\arm_common_tables.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\arm_const_structs.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\arm_math.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\cmsis_armcc.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\cmsis_armclang.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\cmsis_compiler.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\cmsis_gcc.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\cmsis_iccarm.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\cmsis_version.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\core_armv8mbl.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\core_armv8mml.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\core_cm7.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\mpu_armv7.h</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\CMSIS\Include\mpu_armv8.h</name>
        </file>
    </group>
    <group>
        <name>component</name>
        <group>
            <name>lists</name>
            <file>
                <name>$PROJ_DIR$\..\..\components\lists\generic_list.c</name>
            </file>
        </group>
        <group>
            <name>serial_manager</name>
            <file>
                <name>$PROJ_DIR$\..\..\components\serial_manager\serial_manager.c</name>
            </file>
            <file>
                <name>$PROJ_DIR$\..\..\components\serial_manager\serial_port_uart.c</name>
            </file>
        </group>
        <group>
            <name>uart</name>
            <file>
                <name>$PROJ_DIR$\..\..\components\uart\lpuart_adapter.c</name>
            </file>
        </group>
    </group>
    <group>
        <name>device</name>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\system_MIMXRT1052.c</name>
        </file>
    </group>
    <group>
        <name>doc</name>
        <file>
            <name>$PROJ_DIR$\..\readme.txt</name>
        </file>
    </group>
    <group>
        <name>drivers</name>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_adc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_adc_etc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_aipstz.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_aoi.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_bee.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_cache.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_clock.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_cmp.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_common.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_csi.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_dcdc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_dcp.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_dmamux.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_elcdif.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_enc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_enet.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_ewm.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexcan.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_camera.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_camera_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_i2c_master.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_i2s.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_i2s_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_mculcd.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_mculcd_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_spi.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_spi_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_uart.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexio_uart_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexram.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_flexspi.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_gpc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_gpio.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_gpt.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_kpp.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_lpi2c.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_lpi2c_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_lpspi.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_lpspi_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_lpuart.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_lpuart_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_ocotp.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_pit.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_pmu.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_pwm.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_pxp.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_qtmr.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_rtwdog.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_sai.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_sai_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_semc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_snvs_hp.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_snvs_lp.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_spdif.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_spdif_edma.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_src.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_tempmon.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_trng.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_tsc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_usdhc.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_wdog.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_xbara.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\drivers\fsl_xbarb.c</name>
        </file>
    </group>
    <group>
        <name>source</name>
        <file>
            <name>$PROJ_DIR$\..\bsp_i2c_touch.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\bsp_lcd.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\bsp_systick.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\core_delay.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\gt9xx.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\main.c</name>
        </file>
    </group>
    <group>
        <name>startup</name>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\iar\startup_MIMXRT1052.s</name>
        </file>
    </group>
    <group>
        <name>utilities</name>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\utilities\fsl_assert.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\utilities\debug_console\fsl_debug_console.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\..\..\devices\MIMXRT1052\utilities\str\fsl_str.c</name>
        </file>
    </group>
    <group>
        <name>xip</name>
        <file>
            <name>$PROJ_DIR$\fire_imxrt1052_sdram_ini_dcd.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\fire_imxrt1052_spiflash_config.c</name>
        </file>
        <file>
            <name>$PROJ_DIR$\fsl_flexspi_nor_boot.c</name>
        </file>
    </group>
</project>
